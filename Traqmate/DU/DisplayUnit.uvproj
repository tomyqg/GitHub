# Keil uVision project DisplayUnit.uvproj, settings and files
target DU (MCS-51)
  device: C8051F132 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: DisplayUnit +hex
  c flags: Optimize=9
  c define: DISPLAY EXTCLK6 NODEBUG PACKMEM
  c misc: DB
  c include: ..\..\C51\INC\;..\CommonFiles\
  link misc: RECURSIONS (32) CODE (ROADBLOCK (0XFDFE), ?PR?*FDL (0XFE02))
  group Source Group 1
    ./: display.c displayunit.c formatgps.c menu.c timer.c
    ../CommonFiles/: crc.c cygfx120.c cygnalflash.c dataflash.c factorytest.c fdl.c message.c roadblock.c session.c fdlold.SRC
