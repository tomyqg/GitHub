# Keil uVision project SensorUnit.uvproj, settings and files
target SU (MCS-51)
  device: C8051F132 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: SensorUnit +hex
  c flags: Optimize=8
  c define: SENSOR EXTCLK6 NODEBUG UBLOX DISPLAYATTACHED
  c misc: DB OE
  c include: ..\..\C51\INC\;..\CommonFiles\;..\SU\
  link misc: CODE (ROADBLOCK (0XFDFE), ?PR?*FDL (0XFE02))
  group Source Group 1
    ./: adc.c digipot.c lancsetup.c sensorunit.c smbus.c suports.c ubx.c
    ../CommonFiles/: cygfx120.c cygnalflash.c dataflash.c factorytest.c fdl.c message.c session.c roadblock.c crc.c fdlold.SRC
